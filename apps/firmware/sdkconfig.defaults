## apps/firmware/sdkconfig.defaults
```kconfig
CONFIG_LWIP_IP_FORWARD=y
CONFIG_LWIP_IPV4_NAPT=y
CONFIG_LWIP_IP_FORWARD_ALLOW_TX_ON_RX_NETIF=y
CONFIG_LWIP_IP_NAPT_MAX=128
```
